# Keil uVision project MPPT.uvprojx, settings and files
target MPPT (::::)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPPT +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\HARDWARE;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\SPI;..\HARDWARE\MPPT_Output;..\HARDWARE\MPPT_P_O;..\HARDWARE\PWM;..\HARDWARE\Temperature
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c board.c
    ../STM32F10x_FWLib/src/: stm32f10x_spi.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPPT_P_O/: MPPT_P_O.c
    ../HARDWARE/GPIO/: GPIO_init.c
    ../HARDWARE/fuzzy_pid/: fuzzy_pid.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ADC/: ads1256.c
    ../HARDWARE/MPPT_Output/: mppt_output.c
    ../HARDWARE/Temperature/: Temperature.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group README
    ../: README.TXT
